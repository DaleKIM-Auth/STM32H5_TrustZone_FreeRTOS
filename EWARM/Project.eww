<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\NonSecure\Secure_NS.ewp</path>
  </project><project>
    <path>$WS_DIR$\Secure\Secure_S.ewp</path>
  </project>
  <batchBuild />
</workspace>
